IMAGE_INSTALL_append = " rpmsg-modules"
