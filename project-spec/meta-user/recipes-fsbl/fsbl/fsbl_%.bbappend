YAML_APP_CONFIG += " compiler-misc"

YAML_APP_CONFIG[compiler-misc] = "add,-DXPS_BOARD_ZCU102"
