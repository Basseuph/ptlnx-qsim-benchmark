IMAGE_INSTALL_append = " rpmsg-apps"
