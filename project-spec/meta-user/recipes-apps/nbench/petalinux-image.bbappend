IMAGE_INSTALL_append = " nbench"
