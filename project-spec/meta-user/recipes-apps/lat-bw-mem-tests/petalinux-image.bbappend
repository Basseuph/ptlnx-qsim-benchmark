IMAGE_INSTALL_append = " lat-bw-mem-tests"
