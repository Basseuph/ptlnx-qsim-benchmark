SRC_URI_append = " file://inittab"
 
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
